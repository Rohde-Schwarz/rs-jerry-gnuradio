options:
  parameters:
    generate_options: qt_gui
    id: untitled
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: msr4_rs_jerry_0
  id: msr4_rs_jerry
  parameters:
    bandwidth_analysis_bandwidth: '194100000'
    dest_addr: 127.0.0.1
    down_frequency: '0'
    ip_addr: some.device.net
    norm: '1'
    password: password
    port: '5001'
    port_id: '0'
    protocol: msr4.HRZR
    rx_channel: msr4.Rx1
    sat_frequency: '1500000000'
    user: username
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [msr4_rs_jerry_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
